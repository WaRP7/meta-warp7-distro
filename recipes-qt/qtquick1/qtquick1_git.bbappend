PACKAGECONFIG_remove = "webkit"
