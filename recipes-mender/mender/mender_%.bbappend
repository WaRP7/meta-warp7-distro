FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI_append = " file://artifact-verify-key.pem"

SRC_URI_append = " \
		file://mender.conf \
"
