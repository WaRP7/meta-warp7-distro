# Files directory
FILESEXTRAPATHS_prepend := "${THISDIR}/dnsmasq:"

