require u-boot-mender-warp7.inc
