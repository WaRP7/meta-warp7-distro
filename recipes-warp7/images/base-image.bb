DESCRIPTION = "image minimal, to get the hardware running"

inherit base-image
